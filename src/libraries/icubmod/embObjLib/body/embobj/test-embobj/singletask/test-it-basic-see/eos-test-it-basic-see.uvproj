# Keil uVision project eos-test-it-basic-see.uvproj, settings and files
target mcbstm32c (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: eos-test +hex
  c flags: Optim=1
  c misc: --c99
  c include: ..\abslayer-cfg;..\app;..\..\..\embobj\embobj-api;..\..\..\embobj\embobj-src;..\..\..\embobj\embobj-cfg;..\..\..\..\..\sys\abs\api
  asm misc: --cpreproc
  asm include: ..\abslayer-cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group app
    ../app/: eos-test-main.c
  group abs-lib
    ../../../../../sys/abs/lib/: fsal.cm3.lib hal.stm32.mcbstm32c.lib
    ../../../../../sys/abs/src/: hal_stm32_startup.s
    ../abslayer-cfg/: fsal_retarget_slim.c fsal_retarget.c
  group abs-cfg
    ../abslayer-cfg/: hal_cfg.h fsal_cfg.h hal_cfg.c fsal_cfg.c
  group eo-core
    ../../../embobj/embobj-src/: EoCommon.c EOtheErrorManager.c EOtheMemoryPool.c EOVtheSystem.c EOVtheTimerManager.c EOVtask.c EOVmutex.c EOdeque.c EOlist.c EOvector.c EOfifo.c EOfifoByte.c EOfifoWord.c EOaction.c EOtimer.c EOVtheCallbackManager.c
  group eo-see
    ../../../embobj/embobj-src/: EOSmutex.c EOStheFOOP.c EOStheSystem.c EOStheTimerManager.c EOStheCallbackManager.c
