# Keil uVision project eos-minimal-test.uvproj, settings and files
target mcbstm32c (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: eos-test +hex
  c flags: Optim=1
  c misc: --c99
  c include: ..\abslayer-cfg;..\app;..\..\..\embobj\embobj-api;..\..\..\embobj\embobj-src;..\..\..\embobj\embobj-cfg;..\..\..\..\..\sys\abs\api
  asm misc: --cpreproc
  asm include: ..\abslayer-cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group app
    ../app/: eos-test-main.c
  group abslayer-lib
    ../../../../../sys/abs/lib/: fsal.cm3.lib hal.stm32.mcbstm32c.lib
    ../../../../../sys/abs/src/: hal_stm32_startup.s
    ../abslayer-cfg/: fsal_retarget_slim.c fsal_retarget.c
  group abslayer-cfg
    ../abslayer-cfg/: hal_cfg.h fsal_cfg.h hal_cfg.c fsal_cfg.c
  group eov-src
    ../../../embobj/embobj-src/: EOVmutex.c EOVtask.c EOVsmCfg.c EOVtheTimerManager.c EOVtheSystem.c EOVstorage.c
  group eo-src
    ../../../embobj/embobj-src/: EoCommon.c EOtheMemoryPool.c EOtheErrorManager.c EOsm.c EOlist.c EOvector.c EOdeque.c EOfifo.c EOfifoByte.c EOfifoWord.c EOaction.c EOtimer.c EOfakeStorage.c EOarray.c
  group eos-src
    ../../../embobj/embobj-src/: EOSmutex.c EOStheSystem.c EOStheTimerManager.c EOStheFOOP.c EOStheCallbackManager.c
