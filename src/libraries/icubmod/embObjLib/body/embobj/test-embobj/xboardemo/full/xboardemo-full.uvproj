# Keil uVision project xboardemo-full.uvproj, settings and files
target MCBSTM32C (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: udpnode +hex
  c flags: Optim=1
  c define: STM32F10X_CL MCBSTM32C
  c misc: --c99
  c include: ..\app;..\cfg-embobj;..\cfg-abslay;..\..\..\..\..\sys\abs\api;..\..\..\embobj\embobj-api;..\..\..\embobj\embobj-src
  asm misc: --cpreproc
  asm include: ..\cfg-abslay
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group app
    ../app/: xboardemo-main.c
  group abslay-lib
    ../../../../../sys/abs/lib/: osal.cm3.lib fsal.cm3.lib ipal.cm3.lib dspal.cm3.lib hal.stm32.ems001.lib hal.stm32.mcbstm32c.lib
  group abslay-src
    ../../../../../sys/abs/src/: fsal_retarget.c hal_stm32_startup.s
  group abslay-cfg
    ../cfg-abslay/: fsal_cfg.c fsal_cfg.h hal_cfg.c hal_cfg.h ipal_cfg.c ipal_cfg.h osal_cfg.c osal_cfg.h
  group embobj-src
    ../../../embobj/embobj-src/: EOMtheSystem.c EOMtheIPnet.c EOMtheGPIOManager.c EOMtheCallbackManager.c EOMtheTimerManager.c EOMmutex.c EOMtask.c EOVstorage.c EOVtheSystem.c EOVtheIPnet.c EOVtheGPIOManager.c EOVtheTimerManager.c EOVtheGPIOCfg.c EOVtheNVsCfg.c EOVumlsmCfg.c EOVsmCfg.c EOVioPin.c EOVsocket.c EOVmutex.c EOVtask.c EoCommon.c EOtheMemoryPool.c EOtheErrorManager.c EOlist.c EOvector.c EOdeque.c EOfifo.c EOfifoByte.c EOfifoWord.c EOaction.c EOioPinInput.c EOioPinInputManaged.c EOioPinOutput.c EOioPinOutputManaged.c EOtheGPIO.c EOtimer.c EOpacket.c EOdatagramSocket.c EOfakeStorage.c EOarray.c
  group embobj-cfg
    ../cfg-embobj/: EOtheGPIOCfgMCBSTM32x.c EOtheGPIOCfgEMS001.c
target EMS001 (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: udpnode +hex
  c flags: Optim=1
  c define: STM32F10X_CL EMS001
  c misc: --c99
  c include: as above
  asm misc: --cpreproc
  asm include: ..\cfg-abslay
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
