# Keil uVision project eo-udpnode-full.uvproj, settings and files
target Simulator (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=4
  c include: .
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group app
    ../app/: udpnode-main.c nodeAppl_testEth_ems.c nodeAppl_testEth_advanced.c
  group abslayer-lib
    ../../../../../sys/abs/lib/: osal.cm3.lib fsal.cm3.lib hal.stm32f1.mcbstm32c.lib ipal.base.medium.lib
    ../../../../../sys/abs/src/: fsal_retarget.c hal_stm32f1_startup.s
  group abslayer-cfg
    ../abslayer-cfg/: hal_cfg.h fsal_cfg.h osal_cfg.h ipal_cfg.h hal_cfg.c fsal_cfg.c osal_cfg.c ipal_cfg.c
  group docs
    ./: abstract.txt
  group eov-src
    ../../../embobj/embobj-src/: EOVmutex.c EOVtask.c EOVtheTimerManager.c EOVtheIPnet.c EOVtheSystem.c EOVstorage.c EOVtheCallbackManager.c
  group eo-src
    ../../../embobj/embobj-src/: EOtheGPIOManager.c EOioPin.c EoCommon.c EOtheMemoryPool.c EOtheErrorManager.c EOlist.c EOvector.c EOdeque.c EOfifo.c EOfifoByte.c EOfifoWord.c EOaction.c EOioPinInput.c EOioPinInputManaged.c EOioPinOutput.c EOioPinOutputManaged.c EOtheGPIO.c EOtimer.c EOpacket.c EOfakeStorage.c EOarray.c EOsocket.c EOsocketDatagram.c
  group eom-src
    ../../../embobj/embobj-src/: EOMtask.c EOMmutex.c EOMtheTimerManager.c EOMtheCallbackManager.c EOMtheGPIOManager.c EOMtheIPnet.c EOMtheSystem.c
target mcbstm32c (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: udpnode +hex
  c flags: Optim=1
  c define: STM32F10X_CL
  c misc: --c99
  c include: ..\abslayer-cfg;..\app;..\..\..\embobj\embobj-api;..\..\..\embobj\embobj-src;..\..\..\embobj\embobj-cfg;..\..\..\..\..\sys\abs\api;..\..\..\..\..\sys\mid\api;..\..\..\..\..\sys\mid\inc
  asm misc: --cpreproc
  asm include: ..\abslayer-cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
target EMS001-test_eth (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: udpnode +hex
  c flags: Optim=1
  c define: STM32F10X_CL _TEST_ROPS_
  c misc: --c99
  c include: as above
  asm misc: --cpreproc
  asm include: ..\abslayer-cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
target EMS001-test_eth_advanced (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: udpnode +hex
  c flags: Optim=1
  c define: STM32F10X_CL _TEST_ROPS_
  c misc: --c99
  c include: as above
  asm misc: --cpreproc
  asm include: ..\abslayer-cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
