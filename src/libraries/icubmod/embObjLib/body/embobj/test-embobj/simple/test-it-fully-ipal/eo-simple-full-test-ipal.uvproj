# Keil uVision project eo-simple-full-test-ipal.uvproj, settings and files
target Simulator (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=4
  c include: .
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group app
    ../app/: simple-app.c test-eocontainers.c test-eogpio.c test-eomultitask.c test-eosystem.c
  group abslayer-lib
    ../../../../../sys/abs/lib/: osal.cm3.lib hal.stm32.lib fsal.cm3.lib ipal.cm3.lib
    ../../../../../sys/abs/src/: fsal_retarget.c hal_stm32_startup.s
  group abslayer-cfg
    ../abslayer-cfg/: hal_cfg.h fsal_cfg.h osal_cfg.h ipal_cfg.h hal_cfg.c fsal_cfg.c osal_cfg.c ipal_cfg.c
  group docs
    ./: abstract.txt
  group eoall-api
    ../../../embobj/embobj-api/: EoCommon.h EOdeque.h EOfifo.h EOfifoByte.h EOfifoWord.h EOioPinInput.h EOioPinInputManaged.h EOioPinOutput.h EOioPinOutputManaged.h EOlist.h EOtheErrorManager.h EOtheGPIO.h EOtheGPIOManager.h EOtheMemoryPool.h EOVioPin.h EOVmutex.h EOVtask.h EOVtheGPIOCfg.h
  group eov-src
    ../../../embobj/embobj-src/: EOVtheTimerManager.c EOVtask.c EOVioPin.c EOVmutex.c EOVtheSystem.c EOVtheIPnet.c
  group eo-src
    ../../../embobj/embobj-src/: EOVtheGPIOCfg.c EOdeque.c EOtheErrorManager.c EOtheMemoryPool.c EOlist.c EOfifo.c EOfifoByte.c EOfifoWord.c EOtheGPIO.c EOtheGPIOManager.c EOioPinInput.c EOioPinInputManaged.c EOioPinOutput.c EOioPinOutputManaged.c EOtimer.c EOpacket.c EOdatagramSocket.c EOaction.c EoCommon.c
  group eom-src
    ../../../embobj/embobj-src/: EOMmutex.c EOMtask.c EOMtheSystem.c EOMtheTimerManager.c EOMtheCallbackManager.c EOMtheIPnet.c
  group eo-cfg
    ../../../embobj/embobj-cfg/: EOtheGPIOCfgMCBSTM32x.c
  group ipal
    ../../../../abslayer/ipal-package/ipal/ipal-src/: ipal.c
    ../../../../../sys/mid/lib/: ipiit.cm3.lib
    ../../../../../sys/mid/inc/: ipiit_storage.c
target MCBSTM32C (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: embobj-test +hex
  c flags: Optim=1
  c define: STM32F10X_CL
  c include: ..\abslayer-cfg;..\app;..\..\..\embobj\embobj-api;..\..\..\embobj\embobj-src;..\..\..\embobj\embobj-cfg;..\..\..\..\..\sys\abs\api;..\..\..\..\..\sys\mid\api;..\..\..\..\..\sys\mid\inc
  asm misc: --cpreproc
  asm include: ..\abslayer-cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
