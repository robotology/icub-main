# Keil uVision project eo-simple-full-test.uvproj, settings and files
target mcbstm32c (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: embobj-test +hex
  c flags: Optim=1
  c define: STM32F10X_CL
  c misc: --c99
  c include: ..\abslayer-cfg;..\app;..\..\..\embobj\embobj-api;..\..\..\embobj\embobj-src;..\..\..\embobj\embobj-cfg;..\..\..\..\..\sys\abs\api;..\..\..\..\..\sys\mid\api;..\..\..\..\..\sys\mid\inc
  asm misc: --cpreproc
  asm include: ..\abslayer-cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group app
    ../app/: simple-app.c test-eocontainers.c test-eogpio.c test-eomultitask.c test-eosystem.c test-eonetvar.c test-eostatemachine.c
  group abslayer-lib
    ../../../../../sys/abs/lib/: osal.cm3.lib fsal.cm3.lib ipal.cm3.lib hal.stm32.mcbstm32c.lib
    ../../../../../sys/abs/src/: fsal_retarget.c hal_stm32_startup.s
  group abslayer-cfg
    ../abslayer-cfg/: hal_cfg.h fsal_cfg.h osal_cfg.h ipal_cfg.h hal_cfg.c fsal_cfg.c osal_cfg.c ipal_cfg.c
  group docs
    ./: abstract.txt
  group eov-src
    ../../../embobj/embobj-src/: EOVmutex.c EOVtask.c EOVtheSystem.c EOVtheTimerManager.c EOVtheIPnet.c EOVtheNVsCfg.c EOVstorage.c EOVtheCallbackManager.c
  group eo-src
    ../../../embobj/embobj-src/: EoCommon.c EOtheErrorManager.c EOtheMemoryPool.c EOdeque.c EOlist.c EOvector.c EOarray.c EOfifo.c EOfifoByte.c EOfifoWord.c EOaction.c EOtimer.c EOioPinInput.c EOioPinInputManaged.c EOioPinOutput.c EOioPinOutputManaged.c EOtheGPIO.c EOsm.c EOumlsm.c EOtheParser.c EOrop.c EOnetvar.c EOtheNVs.c EOpacket.c EOtheFormer.c EOtheAgent.c EOvport.c EOfakeStorage.c EOnetvarNode.c EOioPin.c EOtheGPIOManager.c EOsocket.c EOsocketDatagram.c
  group eom-src
    ../../../embobj/embobj-src/: EOMmutex.c EOMtask.c EOMtheSystem.c EOMtheTimerManager.c EOMtheCallbackManager.c EOMtheGPIOManager.c EOMtheIPnet.c
  group eo-cfg
    ../../../embobj/embobj-cfg/: EOtheNVsCfgDevice.c EOtheNVsCfgDeviceLoc.c EOtheNVsCfgDeviceLocActions.c EOtheNVsCfgDeviceRem00.c EOtheNVsCfgDeviceRem00Actions.c eOcfg_sm_Ex2.c eOcfg_umlsm_Ex1.c eOcfg_GPIO_MCBSTM32c.c
target simulator (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: embobj-test +hex
  c flags: Optim=1
  c define: STM32F10X_CL _TEST_ROPS_
  c misc: --c99
  c include: as above
  asm misc: --cpreproc
  asm include: ..\abslayer-cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
