# Keil uVision project eom-simple-test-basic-mee.uvproj, settings and files
target mcbstm32c (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: embobj-test +hex
  c flags: Optim=1
  c define: STM32F10X_CL
  c misc: --c99
  c include: ..\abslayer-cfg;..\app;..\..\..\embobj\embobj-api;..\..\..\embobj\embobj-src;..\..\..\embobj\embobj-cfg;..\..\..\..\..\sys\abs\api;..\..\..\..\..\sys\mid\api;..\..\..\..\..\sys\mid\inc
  asm misc: --cpreproc
  asm include: ..\abslayer-cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group app
    ../app/: test-basic-mee-main.c test-basic-mee-appl.c
  group abs-lib
    ../../../../../sys/abs/lib/: hal.stm32.mcbstm32c.lib osal.cm3.lib fsal.cm3.lib
    ../../../../../sys/abs/src/: hal_stm32_startup.s fsal_retarget.c
  group abs-cfg
    ../abslayer-cfg/: hal_cfg.h hal_cfg.c osal_cfg.h osal_cfg.c fsal_cfg.h fsal_cfg.c
  group eo-core
    ../../../embobj/embobj-src/: EoCommon.c EOtheErrorManager.c EOtheMemoryPool.c EOVtheSystem.c EOVtheTimerManager.c EOVtheCallbackManager.c EOVtask.c EOVmutex.c EOdeque.c EOlist.c EOvector.c EOfifo.c EOfifoByte.c EOfifoWord.c EOaction.c EOtimer.c
  group eo-mee
    ../../../embobj/embobj-src/: EOMmutex.c EOMtask.c EOMtheSystem.c EOMtheTimerManager.c EOMtheCallbackManager.c
target simulator (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: embobj-test +hex
  c flags: Optim=1
  c define: STM32F10X_CL _TEST_ROPS_
  c misc: --c99
  c include: as above
  asm misc: --cpreproc
  asm include: ..\abslayer-cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
