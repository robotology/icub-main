# Keil uVision project eo-simple-full-test-osal.uvproj, settings and files
target Simulator (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=4
  c include: .
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group app
    ../app/: simple-app.c test-eocontainers.c test-eogpio.c test-eomultitask.c test-eosystem.c
  group abslayer-lib
    ../../../../../sys/abs/lib/: fsal.cm3.lib hal.stm32.lib ipal.cm3.lib
    ../../../../../sys/abs/src/: fsal_retarget.c hal_stm32_startup.s
  group abslayer-cfg
    ../abslayer-cfg/: hal_cfg.h fsal_cfg.h osal_cfg.h hal_cfg.c fsal_cfg.c osal_cfg.c ipal_cfg.h ipal_cfg.c
  group docs
    ./: abstract.txt
  group eov-src
    ../../../embobj/embobj-src/: EOVioPin.c EOVmutex.c EOVsmCfg.c EOVsocket.c EOVtask.c EOVtheGPIOCfg.c EOVtheGPIOManager.c EOVtheIPnet.c EOVtheNVsCfg.c EOVtheSystem.c EOVtheTimerManager.c EOVumlsmCfg.c
  group eo-src
    ../../../embobj/embobj-src/: EOaction.c EoCommon.c EOdatagramSocket.c EOdeque.c EOfifo.c EOfifoByte.c EOfifoWord.c EOioPinInput.c EOioPinInputManaged.c EOioPinOutput.c EOioPinOutputManaged.c EOlist.c EOnetvar.c EOpacket.c EOrop.c EOsm.c EOsynchroSocket.c EOtheErrorManager.c EOtheGPIO.c EOtheMemoryPool.c EOtheNVs.c EOtheParser.c EOtimer.c EOumlsm.c EOvector.c
  group eom-src
    ../../../embobj/embobj-src/: EOMmutex.c EOMtask.c EOMtheCallbackManager.c EOMtheGPIOManager.c EOMtheIPnet.c EOMtheSystem.c EOMtheTimerManager.c
  group eo-cfg
    ../../../embobj/embobj-cfg/: EOtheGPIOCfgMCBSTM32x.c
  group osal
    ../../../../abslayer/osal-package/osal/osal-src/: osal.c
  group osiit
    ../../../../../sys/mid/lib/: osiit.cm3.lib
    ../../../../../sys/mid/inc/: osiit_storage.c
target MCBSTM32C (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: embobj-test +hex
  c flags: Optim=1
  c define: STM32F10X_CL
  c include: ..\abslayer-cfg;..\app;..\..\..\embobj\embobj-api;..\..\..\embobj\embobj-src;..\..\..\embobj\embobj-cfg;..\..\..\..\abslayer\osal-package\osal\osal-api;..\..\..\..\..\sys\abs\api;..\..\..\..\..\sys\mid\api;..\..\..\..\..\sys\mid\inc
  asm misc: --cpreproc
  asm include: ..\abslayer-cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
