# Keil uVision project eo-nvs-multiple-test.uvproj, settings and files
target mcbstm32c (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: embobj-test +hex
  c flags: Optim=1
  c define: STM32F10X_CL _TEST_ROPS_
  c misc: --c99
  c include: ..\abslayer-cfg;..\app;..\..\..\embobj\embobj-api;..\..\..\embobj\embobj-src;..\..\..\embobj\embobj-cfg;..\..\..\..\..\sys\abs\api;..\..\..\..\..\sys\mid\api;..\..\..\..\..\sys\mid\inc;..\..\..\embobj\embobj-cfg\nvs
  asm misc: --cpreproc
  asm include: ..\abslayer-cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group app
    ../app/: nvs-app.c test-nvs.c test-nvs-somemore.c test-nvs-node00.c
  group abslayer-lib
    ../../../../../sys/abs/lib/: osal.cm3.lib fsal.cm3.lib ipal.cm3.lib hal.stm32.mcbstm32c.lib
    ../../../../../sys/abs/src/: fsal_retarget.c hal_stm32_startup.s
  group abslayer-cfg
    ../abslayer-cfg/: hal_cfg.h fsal_cfg.h osal_cfg.h ipal_cfg.h hal_cfg.c fsal_cfg.c osal_cfg.c ipal_cfg.c
  group docs
    ./: abstract.txt
  group eov-src
    ../../../embobj/embobj-src/: EOVmutex.c EOVtask.c EOVsocket.c EOVioPin.c EOVsmCfg.c EOVumlsmCfg.c EOVtheNVsCfg.c EOVtheGPIOCfg.c EOVtheTimerManager.c EOVtheGPIOManager.c EOVtheIPnet.c EOVtheSystem.c EOVstorage.c
  group eo-src
    ../../../embobj/embobj-src/: EoCommon.c EOtheMemoryPool.c EOtheErrorManager.c EOsm.c EOumlsm.c EOlist.c EOvector.c EOdeque.c EOfifo.c EOfifoByte.c EOfifoWord.c EOaction.c EOioPinInput.c EOioPinInputManaged.c EOioPinOutput.c EOioPinOutputManaged.c EOtheGPIO.c EOtimer.c EOtheParser.c EOrop.c EOnetvar.c EOtheNVs.c EOpacket.c EOdatagramSocket.c EOsynchroSocket.c EOtheFormer.c EOtheAgent.c EOvport.c EOfakeStorage.c EOarray.c EOnetvarNode.c
  group eom-src
    ../../../embobj/embobj-src/: EOMtask.c EOMmutex.c EOMtheTimerManager.c EOMtheCallbackManager.c EOMtheGPIOManager.c EOMtheIPnet.c EOMtheSystem.c
  group eo-cfg-nvs-node00
    ../../../embobj/embobj-cfg/nvs/: EOtheNVsCfgNode00.c EOtheNVsCfgNode00Loc.c EOtheNVsCfgNode00LocActions.c
target simulator (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: embobj-test +hex
  c flags: Optim=1
  c define: STM32F10X_CL _TEST_ROPS_
  c misc: --c99
  c include: ..\abslayer-cfg;..\app;..\..\..\embobj\embobj-api;..\..\..\embobj\embobj-src;..\..\..\embobj\embobj-cfg;..\..\..\..\..\sys\abs\api;..\..\..\..\..\sys\mid\api;..\..\..\..\..\sys\mid\inc
  asm misc: --cpreproc
  asm include: ..\abslayer-cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
