# Keil uVision project eapp-sample.uvproj, settings and files
target mcbstm32c (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: eapp-sample +hex
  c flags: Optim=1
  c misc: --c99
  c include: ..\..\..\..\..\sys\abs\api;..\..\..\envcom;..\..\..\envshalib\shalINFO-package\shalINFO\api;..\..\..\envshalib\shalBASE-package\shalBASE\api;..\..\..\envshalib\shalPART-package\shalPART\api;..\hal-cfg
  asm misc: --cpreproc
  asm include: ..\hal-cfg
  memory RVCT4: ROM 0x8012000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0xfc00
  scatter file: .\eapp-sample.sct
  group application
    ../app/: eapp-sample.c
  group shals-from-body
    ../../../envshalib/shalBASE-package/shalBASE/lib/: shalBASE.mcbstm32c.obj shalBASE.ems001.obj
    ../../../envshalib/shalPART-package/shalPART/lib/: shalPART.mcbstm32c.obj shalPART.ems001.obj
    ../../../envshalib/shalINFO-package/shalINFO/lib/: shalINFO.mcbstm32c.obj shalINFO.ems001.obj
  group hal
    ../hal-cfg/: hal_cfg.h hal_cfg.c
    ../../../../../sys/abs/lib/: hal.stm32f1.mcbstm32c.lib
    ../../../../../sys/abs/src/: hal_stm32f1_startup.s
  group osal
    ../osal-cfg/: osal_cfg.h osal_cfg.c
    ../../../../../sys/abs/lib/: osal.cm3.lib
target ems001 (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: eapp-sample +hex
  c flags: Optim=1
  c define: STM32F10X_CL
  c misc: --c99
  c include: as above
  asm misc: --cpreproc
  asm include: ..\hal-cfg
  memory RVCT4: ROM 0x8012000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0xfc00
  scatter file: .\eapp-sample.sct
