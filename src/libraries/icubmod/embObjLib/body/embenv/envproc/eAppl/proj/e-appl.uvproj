# Keil uVision project e-appl.uvproj, settings and files
target ems (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: eAppl +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_CL
  c misc: --c99
  c include: ..\app;..\hal-cfg;..\fsal-cfg;..\ipal-cfg;..\..\..\..\..\sys\abs\api;..\..\..\envcom;..\..\..\..\embobj\embobj\embobj-api;..\..\..\envshalib\shalBASE-package\shalBASE\api;..\..\..\envshalib\shalPART-package\shalPART\api;..\..\..\envshalib\shalINFO-package\shalINFO\api
  asm misc: --cpreproc
  asm include: ..\hal-cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group app
    ../app/: main.c systemController.c can1mng.c can2mng.c iCubRunningMsg_manager.c CANmng.c encodersReader.c
  group hal
    ../hal-cfg/: hal_cfg.c hal_cfg.h
    ../../../../../sys/abs/src/: hal_stm32f1_startup.s
    ../../../../../sys/abs/lib/: hal.stm32f1.ems001.lib
  group fsal
    ../fsal-cfg/: fsal_cfg.c
    ../../../../../sys/abs/lib/: fsal.cm3.lib
    ../../../../../sys/abs/src/: fsal_retarget.c
  group osal
    ../osal-cfg/: osal_cfg.c
    ../../../../../sys/abs/lib/: osal.cm3.lib
  group ipal
    ../ipal-cfg/: ipal_cfg.c
    ../../../../../sys/abs/lib/: ipal.cm3.lib
  group shal
    ../../../../../sys/env/lib/: shalPART.ems001.obj shalBASE.ems001.obj shalINFO.ems001.obj
  group embObj-core
    ../../../../embobj/embobj/embobj-src/: EOtimer.c EOvector.c EOVmutex.c EOVtask.c EOVtheCallbackManager.c EOVtheSystem.c EOVtheTimerManager.c EOaction.c EoCommon.c EOdeque.c EOfifo.c EOfifoByte.c EOfifoWord.c EOlist.c EOtheErrorManager.c EOtheMemoryPool.c
  group embObj-mee
    ../../../../embobj/embobj/embobj-src/: EOvectorMutex.c EOMmutex.c EOMtask.c EOMtheCallbackManager.c EOMtheEntitiesEnv.c EOMtheSystem.c EOMtheTimerManager.c EOMprodConsSharedData_hid.h EOMprodConsSharedData.c EOMdataContainer_hid.h EOMdataContainer.c
  group embObj-ipnet
    ../../../../embobj/embobj/embobj-src/: EOsocketDatagram.c EOVtheIPnet.c EOMtheIPnet.c EOpacket.c EOsocket.c
