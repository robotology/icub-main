# Keil uVision project eLoader.uvproj, settings and files
target mcbstm32c-hal.lib (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: eLoader +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_CL
  c misc: --c99
  c include: ..\..\..\..\..\sys\abs\api;..\..\..\envcom;..\..\..\envshalib\shalINFO-package\shalINFO\api;..\..\..\envshalib\shalBASE-package\shalBASE\api;..\..\..\envshalib\shalPART-package\shalPART\api;..\..\..\..\..\sys\mid\api;..\..\..\..\..\sys\mid\inc
  asm misc: --cpreproc
  asm include: ..\app
  memory RVCT4: ROM 0x8000000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\eLoader.sct
  group application
    ../app/: loader_STM32F107.c
  group shals-from-body
    ../../../envshalib/shalBASE-package/shalBASE/lib/: shalBASE.ems001.obj shalBASE.mcbstm32c.obj
    ../../../envshalib/shalPART-package/shalPART/lib/: shalPART.ems001.obj shalPART.mcbstm32c.obj
    ../../../envshalib/shalINFO-package/shalINFO/lib/: shalINFO.ems001.obj shalINFO.mcbstm32c.obj
  group hal
    ../app/: hal_cfg.h hal_cfg.c
    ../../../../../sys/abs/src/: hal_stm32f1_startup.s
    ../../../../../sys/abs/lib/: hal.stm32f1.ems001.lib hal.stm32f1.mcbstm32c.lib
target ems001-hal.lib (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: eLoader +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_CL EMS001
  c misc: --c99
  c include: as above
  asm misc: --cpreproc
  asm include: ..\app
  memory RVCT4: ROM 0x8000000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\eLoader.sct
