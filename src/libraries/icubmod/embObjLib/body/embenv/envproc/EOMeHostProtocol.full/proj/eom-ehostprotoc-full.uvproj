# Keil uVision project eom-ehostprotoc-full.uvproj, settings and files
target mcbstm32c (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: udpnode +hex
  c flags: Optim=1
  c define: SHALS_MODE_STATIC EENV_EAPPLICATION_FORCE_CODE_OFFSET_TO_ZERO _FORCE_NETWORK_FROM_IPAL_CFG
  c misc: --c99
  c include: ..\abslayer-cfg;..\app_basic;..\..\..\..\embobj\embobj\embobj-api;..\..\..\..\embobj\embobj\embobj-src;..\..\..\..\embobj\embobj\embobj-cfg;..\..\..\..\..\sys\abs\api;..\..\..\..\..\sys\env\api;..\..\..\..\..\sys\prt;..\app_extra
  asm misc: --cpreproc
  asm include: ..\abslayer-cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\eapp-sample-offset-zero.sct
  group app_basic
    ../app_basic/: eom_hostprotoc_main.c eom_hostprotoc_info.c eom_hostprotoc_specialise.c
    ../app_extra/: eom_hostprotoc_extra.c
  group abslayer-lib
    ../../../../../sys/abs/lib/: osal.cm3.lib hal.stm32f1.mcbstm32c.lib hal.stm32f1.ems001.lib ipal.base.medium.lib osal.cm3.dbg.lib
    ../../../../../sys/abs/src/: hal_stm32f1_startup.s
  group abslayer-cfg
    ../abslayer-cfg/: hal_cfg.c ipal_cfg.c osal_cfg.c hal_cfg.h ipal_cfg.h osal_cfg.h
  group eo-core
    ../../../../embobj/embobj/embobj-src/: EoCommon.c EOtheErrorManager.c EOtheMemoryPool.c EOVtheSystem.c EOVtheTimerManager.c EOVtheCallbackManager.c EOVtask.c EOVmutex.c EOaction.c EOdeque.c EOfifo.c EOfifoByte.c EOfifoWord.c EOlist.c EOtimer.c EOvector.c
  group eo-mee
    ../../../../embobj/embobj/embobj-src/: EOMmutex.c EOMtask.c EOMtheCallbackManager.c EOMtheSystem.c EOMtheTimerManager.c
  group eo-ipnet
    ../../../../embobj/embobj/embobj-src/: EOVtheIPnet.c EOpacket.c EOsocket.c EOsocketDatagram.c EOMtheIPnet.c
  group eo-arm-env
    ../../../../embobj/embobj/embobj-src/: EOVtheEnvironment.c EOtheARMenvironment.c
    ../../../envshalib/shalBASE-package/shalBASE/src/: shalBASE.c
    ../../../envshalib/shalPART-package/shalPART/src/: shalPART.c
    ../../../envshalib/shalINFO-package/shalINFO/src/: shalINFO.c
    ../../../envcom/: eEcommon.c
  group eo-nvs-common
    ../../../../embobj/embobj/embobj-src/: EOarray.c EOconstvector.c EOmatrix3d.c EOnv.c EOnvsCfg.c EOreceiver.c EOrop.c EOropframe.c EOtheAgent.c EOtheFormer.c EOtheParser.c EOtransceiver.c EOtransmitter.c EOtreenode.c EOVstorage.c
  group eo-nvs-host
    ../../../../embobj/embobj/embobj-src/: EOhostTransceiver.c
  group eo-nvs-cfg-common
    ../../../../embobj/embobj/embobj-cfg/: eOcfg_nvsEP_base_con.c eOcfg_nvsEP_mngmnt_con.c
  group eo-nvs-cfg-host
    ../../../../embobj/embobj/embobj-cfg/: eOcfg_nvsEP_mngmnt_usr_rem_board.c eOcfg_nvsEP_base_usr_rem_anydev.c eOcfg_EPs_rem_board.c
  group eo-gpio
    ../../../../embobj/embobj/embobj-src/: EOioPin.c EOioPinInput.c EOioPinInputManaged.c EOioPinOutput.c EOioPinOutputManaged.c EOMtheGPIOManager.c EOtheGPIO.c EOtheGPIOManager.c
  group eo-gpio-cfg
    ../../../../embobj/embobj/embobj-cfg/: eOcfg_GPIO_MCBSTM32c.c
target ems001 (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: udpnode +hex
  c flags: Optim=1
  c define: SHALS_MODE_STATIC
  c misc: --c99
  c include: ..\abslayer-cfg;..\app;..\..\..\..\embobj\embobj\embobj-api;..\..\..\..\embobj\embobj\embobj-src;..\..\..\..\embobj\embobj\embobj-cfg;..\..\..\..\..\sys\abs\api;..\..\..\..\..\sys\env\api
  asm misc: --cpreproc
  asm include: ..\abslayer-cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\e-updater.sct
