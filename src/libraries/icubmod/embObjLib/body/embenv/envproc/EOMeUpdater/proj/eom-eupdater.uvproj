# Keil uVision project eom-eupdater.uvproj, settings and files
target Simulator (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=4
  c include: .
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group app
    ../app/: eom-eupdater-main.c eupdater-info.c eupdater_parser.c updater-core.c
  group abslayer-lib
    ../../../../../sys/abs/lib/: osal.cm3.lib hal.stm32f1.mcbstm32c.lib ipal.base.medium.lib
    ../../../../../sys/abs/src/: hal_stm32f1_startup.s
  group abslayer-cfg
    ../abslayer-cfg/: hal_cfg.c ipal_cfg.c osal_cfg.c hal_cfg.h ipal_cfg.h osal_cfg.h
  group eo-core
    ../../../../embobj/embobj/embobj-src/: EoCommon.c EOtheErrorManager.c EOtheMemoryPool.c EOVtheSystem.c EOVtheTimerManager.c EOVtheCallbackManager.c EOVtask.c EOVmutex.c EOaction.c EOdeque.c EOfifo.c EOfifoByte.c EOfifoWord.c EOlist.c EOtimer.c EOvector.c
  group eo-mee
    ../../../../embobj/embobj/embobj-src/: EOMmutex.c EOMtask.c EOMtheCallbackManager.c EOMtheSystem.c EOMtheTimerManager.c
  group eo-ipnet
    ../../../../embobj/embobj/embobj-src/: EOVtheIPnet.c EOpacket.c EOsocket.c EOsocketDatagram.c EOMtheIPnet.c
  group eo-arm-env
    ../../../../embobj/embobj/embobj-src/: EOVtheEnvironment.c EOtheARMenvironment.c
    ../../../../../sys/env/lib/: shalBASE.mcbstm32c.obj shalPART.mcbstm32c.obj shalINFO.mcbstm32c.obj
target mcbstm32c (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: udpnode +hex
  c flags: Optim=1
  c misc: --c99
  c include: ..\abslayer-cfg;..\app;..\..\..\..\embobj\embobj\embobj-api;..\..\..\..\embobj\embobj\embobj-src;..\..\..\..\embobj\embobj\embobj-cfg;..\..\..\..\..\sys\abs\api;..\..\..\..\..\sys\env\api
  asm misc: --cpreproc
  asm include: ..\abslayer-cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\e-updater.sct
target EMS001-test_eth (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: udpnode +hex
  c flags: Optim=1
  c define: STM32F10X_CL _TEST_ROPS_
  c misc: --c99
  c include: ..\abslayer-cfg;..\app;..\..\..\embobj\embobj-api;..\..\..\embobj\embobj-src;..\..\..\embobj\embobj-cfg;..\..\..\..\..\sys\abs\api;..\..\..\..\..\sys\mid\api;..\..\..\..\..\sys\mid\inc
  asm misc: --cpreproc
  asm include: ..\abslayer-cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
target EMS001-test_eth_advanced (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: udpnode +hex
  c flags: Optim=1
  c define: STM32F10X_CL _TEST_ROPS_
  c misc: --c99
  c include: as above
  asm misc: --cpreproc
  asm include: ..\abslayer-cfg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
