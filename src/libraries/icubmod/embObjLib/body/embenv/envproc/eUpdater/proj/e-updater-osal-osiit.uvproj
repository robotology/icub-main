# Keil uVision project e-updater-osal-osiit.uvproj, settings and files
target mcbstm32c (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: eUpdater +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_CL DBG_MSG OSIIT_USE_EXTERNAL_TREADSAFETY
  c misc: --c99
  c include: ..\app;..\hal-cfg;..\fsal-cfg;..\ipal-cfg;..\..\..\..\..\sys\abs\api;..\..\..\envcom;..\..\..\envshalib\shalBASE-package\shalBASE\api;..\..\..\envshalib\shalPART-package\shalPART\api;..\..\..\envshalib\shalINFO-package\shalINFO\api;.;..\..\..\..\midware\osiit-package\osiit\rl-rtx-modified\CM;..\..\..\..\midware\osiit-package\osiit\osiit-api;..\..\..\..\midware\osiit-package\osiit\osiit-ext\CM;..\..\..\..\midware\osiit-package\osiit\osiit-inc;..\..\..\..\midware\osiit-package\osiit\osiit-stg;.;..\..\..\..\..\sys\mid\api;..\..\..\..\..\sys\mid\inc
  asm misc: --cpreproc
  asm include: ..\hal-cfg
  memory RVCT4: ROM 0x8001000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0xfc00
  group app
    ../app/: app-abslayer.c app-ipnet.c app-telnet.c hexParser.c
  group hal
    ../hal-cfg/: hal_cfg.h hal_cfg.c hal_stm32_startup.s
    ../../../../../sys/abs/lib/: hal.stm32.mcbstm32c.lib
  group fsal
    ../fsal-cfg/: fsal_cfg.h fsal_cfg.c
    ../../../../../sys/abs/lib/: fsal.cm3.lib
    ../../../../../sys/abs/src/: fsal_retarget.c
  group ipal
    ../../../../../sys/abs/lib/: ipal.cm3.lib
    ../ipal-cfg/: ipal_cfg.h ipal_cfg.c
  group shal
    ../../../envshalib/shalBASE-package/shalBASE/lib/: shalBASE.obj
    ../../../envshalib/shalPART-package/shalPART/lib/: shalPART.obj
    ../../../envshalib/shalINFO-package/shalINFO/lib/: shalINFO.obj
  group osal-cfg
    ../osal-cfg/: osal_cfg.h osal_cfg.c
  group osal
    ../../../../abslayer/osal-package/osal/osal-src/: osal.c
    ../../../../../sys/mid/inc/: osiit_storage.c
  group osiit
    ../../../../midware/osiit-package/osiit/rl-rtx-modified/CM/: rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c HAL_CM3.c SVC_Table.s
    ../../../../midware/osiit-package/osiit/osiit-ext/CM/: osiit.c rt_iit_AddOns.c rt_iit_AdvTimer.c rt_iit_memory.c
