# Keil uVision project e-updater.uvproj, settings and files
target mcbstm32c (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: eUpdater +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_CL
  c misc: --c99
  c include: ..\app;..\hal-cfg;..\fsal-cfg;..\ipal-cfg;..\..\..\..\..\sys\abs\api;..\..\..\envcom;..\..\..\envshalib\shalBASE-package\shalBASE\api;..\..\..\envshalib\shalPART-package\shalPART\api;..\..\..\envshalib\shalINFO-package\shalINFO\api;..\updater-core
  asm misc: --cpreproc
  asm include: ..\hal-cfg
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\e-updater.sct
  group app
    ../app/: app-abslayer.c app-ipnet.c
  group updater-core
    ../updater-core/: updater-core.c
  group hal
    ../hal-cfg/: hal_cfg.h hal_cfg.c
    ../../../../../sys/abs/src/: hal_stm32f1_startup.s
    ../../../../../sys/abs/lib/: hal.stm32f1.ems001.lib hal.stm32f1.mcbstm32c.lib
  group osal
    ../../../../../sys/abs/lib/: osal.cm3.lib
    ../osal-cfg/: osal_cfg.h osal_cfg.c
  group ipal
    ../ipal-cfg/: ipal_cfg.h ipal_cfg.c
    ../../../../../sys/abs/lib/: ipal.base.medium.lib
  group shal
    ../../../envshalib/shalBASE-package/shalBASE/lib/: shalBASE.mcbstm32c.obj shalBASE.ems001.obj
    ../../../envshalib/shalPART-package/shalPART/lib/: shalPART.mcbstm32c.obj shalPART.ems001.obj
    ../../../envshalib/shalINFO-package/shalINFO/lib/: shalINFO.mcbstm32c.obj shalINFO.ems001.obj
target ems001 (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: eUpdater +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_CL
  c misc: --c99
  c include: ..\app;..\hal-cfg;..\fsal-cfg;..\ipal-cfg;..\..\..\..\..\sys\abs\api;..\..\..\envcom;..\..\..\envshalib\shalBASE-package\shalBASE\api;..\..\..\envshalib\shalPART-package\shalPART\api;..\..\..\envshalib\shalINFO-package\shalINFO\api
  asm misc: --cpreproc
  asm include: ..\hal-cfg
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\e-updater.sct
