# Keil uVision project e-updater-full-fsal.uvproj, settings and files
target mcbstm32c (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: e-updater +hex
  c flags: Optim=4 OneElfS=1
  c define: STM32F10X_CL
  c include: ..\app;..\hal-cfg;..\fsal-cfg;..\ipal-cfg;..\..\..\..\midware\fsiit-package\fsiit\fsiit-api;..\..\..\..\midware\fsiit-package\fsiit\fsiit-ext;..\..\..\..\midware\fsiit-package\fsiit\fsiit-strg;..\..\..\..\midware\fsiit-package\fsiit\rl-flashfs-modified;..\..\..\..\..\sys\abs\api;..\..\..\..\..\sys\mid\api;..\..\..\..\..\sys\mid\inc;..\..\..\..\..\sys\sha\api
  asm misc: --cpreproc
  asm include: ..\hal-cfg
  memory RVCT4: ROM 0x8004000 size 0x10000
  memory RVCT9: RAM 0x20000400 size 0xfc00
  group app
    ../app/: app-abslayer.c app-ipnet.c app-telnet.c hexParser.c
  group hal
    ../hal-cfg/: hal_cfg.h hal_cfg.c
    ../../../../../sys/abs/lib/: hal.stm32.lib
    ../../../../../sys/abs/src/: hal_stm32_startup.s
  group fsal
    ../../../../../sys/abs/src/: fsal_retarget.c
    ../fsal-cfg/: fsal_cfg.h fsal_cfg.c
  group fsal-fsiit
    ../../../../../sys/mid/lib/: stm32.lib
    ../../../../abslayer/fsal-package/fsal/fsal-src/: fsal.c
    ../../../../midware/fsiit-package/fsiit/fsiit-cfg/: fsiit_flashprog.c
    ../../../../midware/fsiit-package/fsiit/fsiit-ext/: fsiit_AddOns.c
    ../../../../midware/fsiit-package/fsiit/rl-flashfs-modified/: _fs_fclose.c _fs_fcreate.c _fs_fdelete.c _fs_ffind.c _fs_FlashIO.c _fs_flushbuf.c _fs_fopen.c _fs_frename.c _fs_getfsize.c _fs_read.c _fs_setfpos.c _fs_write.c fs_fanalyse.c fs_fat.c fs_fcheck.c fs_fdefrag.c fs_fdelete.c fs_ffind.c fs_fformat.c fs_ffree.c fs_finit.c fs_FlashPrg.c fs_frename.c fs_lib.c fs_mmc.c fs_time.c spi.c
    ../../../../midware/fsiit-package/fsiit/fsiit-stg/: fsiit_storage.c
  group osal
    ../../../../../sys/abs/lib/: osal.cm3.lib
    ../osal-cfg/: osal_cfg.h osal_cfg.c
  group ipal
    ../../../../../sys/abs/lib/: ipal.cm3.lib
    ../ipal-cfg/: ipal_cfg.h ipal_cfg.c
  group shal
    ../../../../../sys/sha/lib/: shalINFO.obj shalIPC.obj shalPART.obj
