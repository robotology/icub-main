# Keil uVision project eLoader.uvproj, settings and files
target mcbstm32c-hal.lib (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: eLoader +hex
  c flags: Optim=4 oTime=1 OneElfS=1
  c define: SHALS_MODE_STATIC
  c misc: --c99
  c include: ..\..\..\..\..\sys\abs\api;..\..\..\envcom;..\..\..\envshalib\shalINFO-package\shalINFO\api;..\..\..\envshalib\shalBASE-package\shalBASE\api;..\..\..\envshalib\shalPART-package\shalPART\api;..\..\..\..\..\sys\mid\api;..\..\..\..\..\sys\mid\inc
  asm misc: --cpreproc
  asm include: ..\app
  memory RVCT4: ROM 0x8000000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\eLoader.sct
  group application
    ../app/: loader_STM32F107.c
  group shals-src
    ../../../envshalib/shalBASE-package/shalBASE/src/: shalBASE.c
    ../../../envshalib/shalPART-package/shalPART/src/: shalPART.c
    ../../../envshalib/shalINFO-package/shalINFO/src/: shalINFO.c
    ../../../envcom/: eEcommon.c
  group hal
    ../app/: hal_cfg.h hal_cfg.c
    ../../../../../sys/abs/lib/: hal.stm32f1.ems001.lib hal.stm32f1.mcbstm32c.lib
    ../../../../../sys/abs/src/: hal_stm32f1_startup.s
target ems001-hal.lib (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: eLoader +hex
  c flags: Optim=4 oTime=1 OneElfS=1
  c define: EMS001 SHALS_MODE_STATIC
  c misc: --c99
  c include: as above
  asm misc: --cpreproc
  asm include: ..\app
  memory RVCT4: ROM 0x8000000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\eLoader.sct
