# Keil uVision project shalinfo-full.uvproj, settings and files
target mcbstm32c (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: CMSIS_Example
  c flags: Optim=1
  c define: STM32F10X_CL
  c misc: --c99
  c include: ..\..\shalINFO\api;..\..\..\api;..\..\..\shalPART-package\shalPART\api;..\..\..\..\envcom;..\..\..\shalBASE-package\shalBASE\api;..\..\..\..\..\..\sys\abs\api;..\app-test
  asm misc: --cpreproc
  asm include: ..\hal-cfg
  memory RVCT4: ROM 0x8000000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x20
  memory RVCT10: RAM 0x20000400 size 0xffe0
  group application
    ../app-test/: main_STM32F107.c
  group shalinfo
    ../../shalINFO/src/: shalINFO.c
  group hal
    ../../../../../../sys/abs/lib/: hal.stm32.mcbstm32c.slim.lib
    ../../../../../../sys/abs/src/: hal_stm32_startup.s
    ../hal-cfg/: hal_cfg.h hal_cfg.c
  group shalpart-from-body
    ../../../shalPART-package/shalPART/lib/: shalPART.obj
  group shalbase-from-body
    ../../../shalBASE-package/shalBASE/lib/: shalBASE.obj
