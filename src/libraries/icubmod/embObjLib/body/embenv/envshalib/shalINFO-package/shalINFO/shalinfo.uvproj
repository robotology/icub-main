# Keil uVision project shalinfo.uvproj, settings and files
target mcbstm32c (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: shalINFO_mcbstm32c +hex
  AfterMake: cmd.exe /C copy .\Obj\shalINFO_mcbstm32c.hex .\bin\shalINFO.mcbstm32c.hex
  c flags: Optim=1
  c define: STM32F10X_CL EECOMMON_DONTUSESTRGFLASH
  c misc: --c99
  c include: .\api;..\..\shalPART-package\shalPART\api;..\..\..\envcom;..\..\..\..\..\sys\abs\api;..\..\shalBASE-package\shalBASE\api
  memory RVCT4: ROM 0x8003000 size 0x800
  memory RVCT9: RAM 0x20000000 size 0x20
  scatter file: .\shalINFO.sct
  link misc: --entry shalinfo_init --symdefs .\lib\shalINFO.mcbstm32c.obj
  group shalbase-from-body
    ../../shalBASE-package/shalBASE/lib/: shalBASE.mcbstm32c.obj shalBASE.ems001.obj
  group shalpart-from-body
    ../../shalPART-package/shalPART/lib/: shalPART.mcbstm32c.obj shalPART.ems001.obj
  group shalinfo
    ./src/: shalINFO.c
    ../../../envcom/: eEcommon.c
target ems001 (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: shalINFO_ems001 +hex
  AfterMake: cmd.exe /C copy .\Obj\shalINFO_ems001.hex .\bin\shalINFO.ems001.hex
  c flags: Optim=4 oTime=1
  c define: STM32F10X_CL EECOMMON_DONTUSESTRGFLASH
  c misc: --c99
  c include: as above
  memory RVCT4: ROM 0x8003000 size 0x800
  memory RVCT9: RAM 0x20000000 size 0x20
  scatter file: .\shalINFO.sct
  link misc: --entry shalinfo_init --symdefs .\lib\shalINFO.ems001.obj
