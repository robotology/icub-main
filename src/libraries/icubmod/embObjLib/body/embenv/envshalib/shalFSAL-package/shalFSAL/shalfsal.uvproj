# Keil uVision project shalfsal.uvproj, settings and files
target shalfsal.mcbstm32c (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: shalFSALcm3 +hex
  AfterMake: cmd.exe /C copy .\Obj\shalFSALcm3.hex .\bin\shalFSALcm3.hex
  c flags: Optim=1
  c define: STM32F10X_CL
  c misc: --c99
  c include: .\api;..\..\..\envcom;..\..\..\..\abslayer\osal-package\fsal\osal-api;..\..\..\..\..\sys\mid\inc;..\..\..\..\..\sys\mid\api;..\..\..\..\..\sys\abs\api
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\shalFSAL.sct
  link misc: --entry shalfsal_entrypoint --symdefs .\lib\shalFSAL.cm3.obj
  group fsiit-from-sys
    ../../../../../sys/mid/lib/: fsiit.cm3.lib
    ../../../../../sys/mid/inc/: fsiit_storage.c
  group fsal-from-body
    ../../../../abslayer/fsal-package/fsal/fsal-src/: fsal.c
  group shal-fsal
    ./src/: shalFSAL.c
target shalfsal.ems001 (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: shalHAL.ems001 (library)
  AfterMake: cmd.exe /C copy .\Obj\shalHAL.ems001.hex .\bin\shalHAL.ems001.hex
  c flags: Optim=4 oTime=1
  c define: STM32F10X_CL USE_EMS001_BOARD HAL_USE_DISPLAY HAL_USE_ETH HAL_USE_FLASH HAL_USE_GPIO HAL_USE_SYS HAL_USE_CAN HAL_USE_EEPROM HAL_USE_SPI HAL_USE_I2C
  c misc: --c99
  c include: ..\hal\hal-api;..\..\..\..\sys\mid\api;..\..\..\..\sys\mid\inc;.\hal-src\stm32
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\shalHAL.sct
  link misc: --entry shalhal_entrypoint --symdefs .\lib\shalHAL.ems001.obj
