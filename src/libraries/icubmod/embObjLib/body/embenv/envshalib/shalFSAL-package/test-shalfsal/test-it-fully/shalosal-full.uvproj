# Keil uVision project shalosal-full.uvproj, settings and files
target mcsbstm2c (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: mcbstm32c
  c flags: Optim=1
  c define: STM32F10X_CL
  c misc: --c99
  c include: ..\..\shalFSAL\api;..\hal-cfg;..\..\..\..\envcom;..\fsal-cfg;..\..\..\..\..\..\sys\abs\api;..\..\..\..\..\..\sys\mid\api;..\..\..\..\..\..\sys\mid\inc
  asm misc: --cpreproc
  asm include: ..\hal-cfg
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT10: RAM 0x20001000 size 0xf000
  group application
    ../app-test/: main_STM32F107.c
  group shalfsal-src
    ../../../../../../sys/mid/lib/: fsiit.cm3.lib
    ../../../../../../sys/mid/inc/: fsiit_storage.c
    ../../../../../abslayer/fsal-package/fsal/fsal-src/: fsal.c fsal_flashprog.c
    ../../shalFSAL/src/: shalFSAL.c hal_flashprog.c
  group hal
    ../../../../../../sys/abs/lib/: hal.stm32.mcbstm32c.lib
    ../../../../../../sys/abs/src/: hal_stm32_startup.s
    ../hal-cfg/: hal_cfg.h hal_cfg.c
  group fsal-cfg
    ../fsal-cfg/: fsal_cfg.h fsal_cfg.c
  group fsal-retarget
    ../../../../../../sys/abs/src/: fsal_retarget.c
