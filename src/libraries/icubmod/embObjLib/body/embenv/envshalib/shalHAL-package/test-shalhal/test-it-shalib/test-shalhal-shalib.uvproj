# Keil uVision project test-shalhal-shalib.uvproj, settings and files
target mcsbstm2c (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: loader
  c flags: Optim=1
  c define: STM32F10X_CL
  c misc: --c99
  c include: ..\..\shalHAL\api;..\hal-cfg;..\..\..\..\..\abslayer\hal-package\hal\hal-api;..\..\..\..\envcom
  asm misc: --cpreproc
  asm include: ..\hal-cfg
  memory RVCT4: ROM 0x8000000 size 0x1000
  memory RVCT10: RAM 0x20000000 size 0xa000
  group application
    ../app-test/: main_STM32F107.c
  group shalhal-from-body
    ../../shalHAL/lib/: shalHAL.mcbstm32c.obj
  group hal
    ../hal-cfg/: hal_cfg.h hal_cfg.c
    ../../../../../../sys/abs/src/: hal_stm32_startup.s
