# Keil uVision project shalhal.uvproj, settings and files
target shalhal.mcbstm32c (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: shalHALmcbstm32c +hex
  AfterMake: cmd.exe /C copy .\Obj\shalHALmcbstm32c.hex .\bin\shalHALmcbstm32c.hex
  c flags: Optim=4 oTime=1
  c define: STM32F10X_CL USE_MCBSTM32C_BOARD HAL_USE_ETH  HAL_USE_FLASH HAL_USE_GPIO HAL_USE_SYS HAL_USE_CAN HAL_USE_EEPROM HAL_USE_SPI HAL_USE_I2C
  c misc: --c99
  c include: ..\..\..\..\abslayer\hal-package\hal\hal-api;..\..\..\..\abslayer\hal-package\hal\hal-src\stm32;..\..\..\..\..\sys\mid\api;..\..\..\..\..\sys\mid\inc;.\api;..\..\..\envcom
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\shalHAL.sct
  link misc: --entry shalhal_entrypoint --symdefs .\lib\shalHAL.mcbstm32c.obj
  group cmsis-from-sys
    ../../../../../sys/mid/src/: core_cm3.c system_stm32f10x.c
  group stm32-from-sys
    ../../../../../sys/mid/lib/: stm32.lib
  group hal-stm32
    ../../../../abslayer/hal-package/hal/hal-src/stm32/: hal_stm32.c hal_stm32_display.c hal_stm32_display_GLCD_SPI_STM32.c hal_stm32_eth.c hal_stm32_flash.c hal_stm32_gpio.c hal_stm32_sys.c hal_stm32_can.c hal_stm32_eeprom.c hal_stm32_spi.c hal_board_config.c hal_stm32_i2c.c
  group stm32-utility
    ../../../../abslayer/hal-package/hal/hal-src/stm32/stm32_utility/: stm32_eval_i2c_ee.c stm32_eval_i2c_ee.h
  group shal-hal
    ./src/: shalHAL.c
target shalhal.ems001 (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: shalHAL.ems001 (library)
  AfterMake: cmd.exe /C copy .\Obj\shalHAL.ems001.hex .\bin\shalHAL.ems001.hex
  c flags: Optim=4 oTime=1
  c define: STM32F10X_CL USE_EMS001_BOARD HAL_USE_DISPLAY HAL_USE_ETH HAL_USE_FLASH HAL_USE_GPIO HAL_USE_SYS HAL_USE_CAN HAL_USE_EEPROM HAL_USE_SPI HAL_USE_I2C
  c misc: --c99
  c include: ..\hal\hal-api;..\..\..\..\sys\mid\api;..\..\..\..\sys\mid\inc;.\hal-src\stm32
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\shalHAL.sct
  link misc: --entry shalhal_entrypoint --symdefs .\lib\shalHAL.ems001.obj
