# Keil uVision project shalhal-full.uvproj, settings and files
target mcsbstm2c (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: loader
  c flags: Optim=1
  c define: STM32F10X_CL USE_MCBSTM32C_BOARD HAL_USE_ETH  HAL_USE_FLASH HAL_USE_GPIO HAL_USE_SYS HAL_USE_CAN HAL_USE_EEPROM HAL_USE_SPI HAL_USE_I2C
  c misc: --c99
  c include: ..\..\shalHAL\api;..\..\..\api;..\..\..\..\..\..\sys\mid\api;..\..\..\..\..\..\sys\mid\inc;..\..\..\..\envcom;..\..\..\..\..\..\sys\abs\api;..\..\..\..\..\abslayer\hal-package\hal\hal-src\stm32
  asm misc: --cpreproc
  asm include: ..\hal-cfg
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT10: RAM 0x20001000 size 0xf000
  group application
    ../app-test/: main_STM32F107.c
  group shalhal-cmsis
    ../../../../../../sys/mid/src/: core_cm3.c system_stm32f10x.c
  group hal
    ../hal-cfg/: hal_cfg.h hal_cfg.c
    ../../../../../../sys/abs/src/: hal_stm32_startup.s
  group shalhal-stm32lib
    ../../../../../../sys/mid/lib/: stm32.lib
  group shalhal-hal-src
    ../../../../../abslayer/hal-package/hal/hal-src/stm32/: hal_stm32.c hal_stm32_display.c hal_stm32_display_GLCD_SPI_STM32.c hal_stm32_eth.c hal_stm32_flash.c hal_stm32_gpio.c hal_stm32_sys.c hal_stm32_can.c hal_stm32_eeprom.c hal_stm32_spi.c hal_board_config.c hal_stm32_i2c.c
    ../../../../../abslayer/hal-package/hal/hal-src/stm32/stm32_utility/: stm32_eval_i2c_ee.c
  group shalhal-src
    ../../shalHAL/src/: shalHAL.c
