# Keil uVision project test-shalosal-shalhal-shalib.uvproj, settings and files
target mcsbstm2c (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: loader
  c flags: Optim=1
  c define: STM32F10X_CL USESHALHAL
  c misc: --c99
  c include: ..\..\shalOSAL\api;..\hal-cfg;..\..\..\..\envcom;..\osal-cfg;..\..\..\..\..\..\sys\abs\api;..\..\..\shalHAL-package\shalHAL\api
  asm misc: --cpreproc
  asm include: ..\hal-cfg
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0xa000
  group application
    ../app-test/: main_STM32F107.c
  group shalosal-from-body
    ../../shalOSAL/lib/: shalOSAL.cm3.obj
  group hal
    ../hal-cfg/: hal_cfg.h hal_cfg.c
    ../../../../../../sys/abs/src/: hal_stm32_startup.s
    ../../../shalHAL-package/shalHAL/lib/: shalHAL.mcbstm32c.obj
  group osal-cfg
    ../osal-cfg/: osal_cfg.h osal_cfg.c
