# Keil uVision project shalosal.uvproj, settings and files
target shalosal.mcbstm32c (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: shalOSALcm3 +hex
  AfterMake: cmd.exe /C copy .\Obj\shalOSALcm3.hex .\bin\shalOSALcm3.hex
  c flags: Optim=1
  c define: OSIIT_USE_EXTERNAL_TREADSAFETY
  c misc: --c99
  c include: .\api;..\..\..\envcom;..\..\..\..\abslayer\osal-package\osal\osal-api;..\..\..\..\..\sys\mid\inc;..\..\..\..\..\sys\mid\api
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\shalOSAL.sct
  link misc: --entry shalosal_entrypoint --symdefs .\lib\shalOSAL.cm3.obj
  group osiit-from-sys
    ../../../../../sys/mid/lib/: osiit.cm3.lib
    ../../../../../sys/mid/inc/: osiit_storage.c
  group osal-from-body
    ../../../../abslayer/osal-package/osal/osal-src/: osal.c
  group shal-osal
    ./src/: shalOSAL.c
target shalosal.ems001 (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: shalHAL.ems001 (library)
  AfterMake: cmd.exe /C copy .\Obj\shalHAL.ems001.hex .\bin\shalHAL.ems001.hex
  c flags: Optim=4 oTime=1
  c define: STM32F10X_CL USE_EMS001_BOARD HAL_USE_DISPLAY HAL_USE_ETH HAL_USE_FLASH HAL_USE_GPIO HAL_USE_SYS HAL_USE_CAN HAL_USE_EEPROM HAL_USE_SPI HAL_USE_I2C
  c misc: --c99
  c include: ..\hal\hal-api;..\..\..\..\sys\mid\api;..\..\..\..\sys\mid\inc;.\hal-src\stm32
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\shalHAL.sct
  link misc: --entry shalhal_entrypoint --symdefs .\lib\shalHAL.ems001.obj
