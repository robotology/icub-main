# Keil uVision project shalosal-full.uvproj, settings and files
target mcsbstm2c (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: mcbstm32c
  c flags: Optim=1
  c define: OSIIT_USE_EXTERNAL_TREADSAFETY
  c misc: --c99
  c include: ..\..\..\..\..\..\sys\mid\api;..\..\..\..\..\..\sys\mid\inc;..\..\..\..\envcom;..\..\..\..\..\..\sys\abs\api;..\..\shalOSAL\api
  asm misc: --cpreproc
  asm include: ..\hal-cfg
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT10: RAM 0x20001000 size 0xf000
  group application
    ../app-test/: main_STM32F107.c
  group shalosal-src
    ../../../../../../sys/mid/lib/: osiit.cm3.lib
    ../../../../../../sys/mid/inc/: osiit_storage.c
    ../../shalOSAL/src/: shalOSAL.c
    ../../../../../abslayer/osal-package/osal/osal-src/: osal.c
  group hal
    ../../../../../../sys/abs/lib/: hal.stm32.mcbstm32c.lib
    ../../../../../../sys/abs/src/: hal_stm32_startup.s
    ../hal-cfg/: hal_cfg.h hal_cfg.c
  group osal-cfg
    ../osal-cfg/: osal_cfg.h osal_cfg.c
