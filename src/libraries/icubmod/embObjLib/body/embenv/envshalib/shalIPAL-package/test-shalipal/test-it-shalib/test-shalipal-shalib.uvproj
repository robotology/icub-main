# Keil uVision project test-shalipal-shalib.uvproj, settings and files
target mcsbstm2c (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: loader
  c flags: Optim=1
  c define: STM32F10X_CL
  c misc: --c99
  c include: ..\..\shalIPAL\api;..\hal-cfg;..\..\..\..\envcom;..\fsal-cfg;..\..\..\..\..\..\sys\abs\api
  asm misc: --cpreproc
  asm include: ..\hal-cfg
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0xc800
  group application
    ../app-test/: Telnet_demo.c
  group shalipal-from-body
    ../../shalIPAL/lib/: shalIPAL.cm3.obj
  group ipal-cfg
    ../ipal-cfg/: ipal_cfg.h ipal_cfg.c
  group hal
    ../hal-cfg/: hal_cfg.h hal_cfg.c
    ../../../../../../sys/abs/src/: hal_stm32_startup.s
    ../../../../../../sys/abs/lib/: hal.stm32.mcbstm32c.lib
  group fsal
    ../fsal-cfg/: fsal_cfg.h fsal_cfg.c
    ../../../../../../sys/abs/lib/: fsal.cm3.lib
    ../../../../../../sys/abs/src/: fsal_retarget.c
