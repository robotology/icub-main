# Keil uVision project shalipal.uvproj, settings and files
target shalipal.cm3 (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: shalIPALcm3 +hex
  AfterMake: cmd.exe /C copy .\Obj\shalIPALcm3.hex .\bin\shalIPALcm3.hex
  c flags: Optim=1
  c define: STM32F10X_CL
  c misc: --c99
  c include: .\api;..\..\..\envcom;..\..\..\..\..\sys\mid\inc;..\..\..\..\..\sys\mid\api;..\..\..\..\..\sys\abs\api
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\shalIPAL.sct
  link misc: --entry shalipal_entrypoint --symdefs .\lib\shalIPAL.cm3.obj
  group ipal-from-body
    ../../../../abslayer/ipal-package/ipal/ipal-src/: ipal.c
  group ipiit-from-sys
    ../../../../../sys/mid/lib/: ipiit.cm3.lib
  group shal-ipal
    ./src/: shalIPAL.c
