# Keil uVision project shalpart-shalib.uvproj, settings and files
target mcbstm32c (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: CMSIS_Example
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_CL
  c misc: --c99
  c include: ..\..\shalPART\api;..\..\..\..\envcom;..\..\..\..\..\..\sys\abs\api;..\..\..\shalBASE-package\shalBASE\api
  asm misc: --cpreproc
  asm include: ..\hal-cfg
  memory RVCT4: ROM 0x8000000 size 0x1000
  memory RVCT9: RAM 0x20002000 size 0xf000
  memory RVCT10: RAM 0x20000000 size 0x1000
  group application
    ../app-test/: main_STM32F107.c
  group shalpart-from-shalib
    ../../shalPART/lib/: shalPART.obj
  group very-important-readme
    ./: shalpart-shalib.readme-first.txt
  group hal
    ../../../../../../sys/abs/lib/: hal.stm32.mcbstm32c.slim.lib
    ../../../../../../sys/abs/src/: hal_stm32_startup.s
    ../hal-cfg/: hal_cfg.h hal_cfg.c
  group shalbase-from-shalib
    ../../../shalBASE-package/shalBASE/lib/: shalBASE.obj
