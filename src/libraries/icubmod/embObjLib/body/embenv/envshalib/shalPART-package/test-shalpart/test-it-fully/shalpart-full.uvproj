# Keil uVision project shalpart-full.uvproj, settings and files
target mcbstm32c (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: CMSIS_Example
  c flags: Optim=1 OneElfS=1
  c define: TEST_NO_OSIIT STM32F10X_CL USE_STDPERIPH_DRIVER USE_MCBSTM32C_BOARD  HAL_USE_DISPLAY HAL_USE_ETH HAL_USE_FLASH HAL_USE_GPIO HAL_USE_SYS HAL_USE_CAN HAL_USE_EEPROM HAL_USE_SPI HAL_USE_I2C
  c misc: --c99
  c include: ..\..\shalPART\api;..\..\..\..\envcom;..\..\..\..\..\..\sys\abs\api;..\..\..\..\..\..\sys\mid\api;..\..\..\..\..\..\sys\mid\inc;..\..\..\..\..\..\sys\abs\api;..\..\..\..\..\abslayer\hal-package\hal\hal-src\stm32;..\..\..\..\..\midware\stm32-package\stm32\stm32-ext;..\..\..\..\..\midware\stm32-package\stm32\stm32-src;..\..\..\shalBASE-package\shalBASE\api
  asm misc: --cpreproc
  asm include: ..\hal-cfg
  memory RVCT4: ROM 0x8000000 size 0x6000
  memory RVCT10: RAM 0x20002000 size 0xf000
  group application
    ../app-test/: main_STM32F107.c
  group shalpart
    ../../shalPART/src/: shalPART.c
  group shalbase
    ../../../shalBASE-package/shalBASE/src/: shalBASE.c
  group hal
    ../../../../../../sys/abs/src/: hal_stm32_startup.s
    ../../../../../../sys/abs/lib/: hal.stm32.mcbstm32c.slim.lib
    ../hal-cfg/: hal_cfg.h hal_cfg.c
