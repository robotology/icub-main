# Keil uVision project shalpart.uvproj, settings and files
target mcbstm32c (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: shalPART_mcbstm32c +hex
  AfterMake: cmd.exe /C copy .\Obj\shalPART_mcbstm32c.hex .\bin\shalPART.mcbstm32c.hex
  c flags: Optim=1
  c define: STM32F10X_CL EECOMMON_DONTUSESTRGFLASH
  c misc: --c99
  c include: .\api;..\..\..\..\..\sys\mid\api;..\..\..\..\..\sys\mid\inc;..\..\..\envcom;..\..\..\..\..\sys\abs\api;..\..\shalBASE-package\shalBASE\api
  memory RVCT4: ROM 0x8001000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x100
  scatter file: .\shalPART.sct
  link misc: --entry shalpart_hid_entrypoint --symdefs .\lib\shalPART.mcbstm32c.obj
  group shalpart
    ./src/: shalPART.c
  group read.me
    ./docs/: warning.txt
  group shalBASE
    ../../shalBASE-package/shalBASE/lib/: shalBASE.mcbstm32c.obj shalBASE.ems001.obj
target ems001 (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: shalPART_ems001 +hex
  AfterMake: cmd.exe /C copy .\Obj\shalPART_ems001.hex .\bin\shalPART.ems001.hex
  c flags: Optim=4 oTime=1
  c define: STM32F10X_CL EECOMMON_DONTUSESTRGFLASH
  c misc: --c99
  c include: as above
  memory RVCT4: ROM 0x8001000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x100
  scatter file: .\shalPART.sct
  link misc: --entry shalpart_hid_entrypoint --symdefs .\lib\shalPART.ems001.obj
