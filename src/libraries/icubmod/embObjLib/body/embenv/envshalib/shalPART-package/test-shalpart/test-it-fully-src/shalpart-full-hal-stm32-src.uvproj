# Keil uVision project shalpart-full-hal-stm32-src.uvproj, settings and files
target mcbstm32c (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: CMSIS_Example
  c flags: Optim=1 OneElfS=1
  c define: TEST_NO_OSIIT STM32F10X_CL USE_STDPERIPH_DRIVER USE_MCBSTM32C_BOARD  HAL_USE_DISPLAY HAL_USE_ETH HAL_USE_FLASH HAL_USE_GPIO HAL_USE_SYS HAL_USE_CAN HAL_USE_EEPROM HAL_USE_SPI HAL_USE_I2C
  c misc: --c99
  c include: ..\..\shalPART\api;..\..\..\..\envcom;..\..\..\..\..\..\sys\abs\api;..\..\..\..\..\..\sys\mid\api;..\..\..\..\..\..\sys\mid\inc;..\..\..\..\..\..\sys\abs\api;..\..\..\..\..\abslayer\hal-package\hal\hal-src\stm32;..\..\..\..\..\midware\stm32-package\stm32\stm32-ext;..\..\..\..\..\midware\stm32-package\stm32\stm32-src;..\..\..\shalBASE-package\shalBASE\api
  asm misc: --cpreproc
  asm include: ..\app-test
  memory RVCT4: ROM 0x8000000 size 0x6000
  memory RVCT10: RAM 0x20002000 size 0xf000
  group application
    ../app-test/: main_STM32F107.c
  group hal
    ../../../../../../sys/abs/src/: hal_stm32_startup.s
    ../hal-cfg/: hal_cfg.h hal_cfg.c
  group shalpart
    ../../shalPART/src/: shalPART.c
  group shalbase
    ../../../shalBASE-package/shalBASE/src/: shalBASE.c
  group cmsis-from-sys-for-hal-stm32-src
    ../../../../../../sys/mid/src/: core_cm3.c system_stm32f10x.c
  group hal-stm32-src
    ../../../../../abslayer/hal-package/hal/hal-src/stm32/: hal_stm32.c hal_stm32_display.c hal_stm32_eeprom.c hal_stm32_eth.c hal_stm32_display_GLCD_SPI_STM32.c hal_stm32_flash.c hal_stm32_gpio.c hal_stm32_i2c.c hal_stm32_spi.c hal_stm32_sys.c hal_stm32_can.c hal_board_config.c
    ../../../../../abslayer/hal-package/hal/hal-src/stm32/stm32_utility/: stm32_eval_i2c_ee.c
  group stm32-src
    ../../../../../midware/stm32-package/stm32/stm32-src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
