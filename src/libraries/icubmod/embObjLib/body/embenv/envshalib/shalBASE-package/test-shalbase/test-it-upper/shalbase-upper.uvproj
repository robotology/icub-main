# Keil uVision project shalbase-upper.uvproj, settings and files
target mcbstm32 (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: CMSIS_Example
  c flags: Optim=1
  c define: STM32F10X_CL
  c misc: --c99
  c include: ..\..\..\api;..\..\..\..\..\..\sys\mid\api;..\..\..\..\..\..\sys\mid\inc;..\..\..\..\envcom;..\..\..\shalPART-package\shalPART\api;..\..\shalBASE\api
  memory RVCT4: ROM 0x8020000 size 0x2000
  memory RVCT10: RAM 0x20002000 size 0x2000
  group cmsis-from-sys
    ../../../../../../sys/mid/src/: core_cm3.c system_stm32f10x.c
  group cmsis-cfg-local
    ../cmsis-cfg/stm32-armcc/: startup_stm32f10x_cl.s
  group application
    ../app-test/: upper_STM32F107.c
  group shalbase-from-body
    ../../shalBASE/lib/: shalBASE.obj
  group stm32-from-sys
    ../../../../../midware/stm32-package/stm32/stm32-lib/: stm32.lib
  group very-important-readme
    ./: shalipc-upper.readme-first.txt
  group shalpart-from-body
    ../../../shalPART-package/shalPART/lib/: shalPART.obj
