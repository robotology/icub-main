# Keil uVision project shalbase.uvproj, settings and files
target mcbstm32c (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: shalBASE_mcbstm32c +hex
  AfterMake: cmd.exe /C copy .\Obj\shalBASE_mcbstm32c.hex .\bin\shalBASE.mcbstm32c.hex
  c flags: Optim=1
  c define: STM32F10X_CL EECOMMON_DONTUSESTRGFLASH
  c misc: --c99
  c include: .\api;..\..\..\..\..\sys\mid\api;..\..\..\..\..\sys\mid\inc;..\..\..\envcom;..\..\..\..\..\sys\abs\api;..\..\shalPART-package\shalPART\api
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\shalBASE.sct
  link misc: --entry shalbase_entrypoint --symdefs .\lib\shalBASE.mcbstm32c.obj
  group shalbase
    ./src/: shalBASE.c
  group hal
    ../../../../../sys/abs/lib/: hal.stm32f1.ems001.slim.lib hal.stm32f1.mcbstm32c.slim.lib
target ems001 (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: shalBASE_ems001 +hex
  AfterMake: cmd.exe /C copy .\Obj\shalBASE_ems001.hex .\bin\shalBASE.ems001.hex
  c flags: Optim=4 oTime=1
  c define: STM32F10X_CL EECOMMON_DONTUSESTRGFLASH
  c misc: --c99
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\shalBASE.sct
  link misc: --entry shalbase_entrypoint --symdefs .\lib\shalBASE.ems001.obj
