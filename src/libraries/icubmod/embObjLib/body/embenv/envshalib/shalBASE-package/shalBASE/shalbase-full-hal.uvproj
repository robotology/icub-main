# Keil uVision project shalbase-full-hal.uvproj, settings and files
target mcbstm32c-hal (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: shalBASE +hex
  AfterMake: cmd.exe /C copy .\Obj\shalBASE.hex .\bin\shalBASE.hex
  c flags: Optim=4 oTime=1 OneElfS=1
  c define: STM32F10X_CL DONTOPTIMISEBASE EECOMMON_DONTUSESTRGFLASH USE_MCBSTM32C_BOARD HAL_USE_FLASH HAL_USE_GPIO HAL_USE_SYS HAL_USE_EEPROM HAL_USE_I2C
  c misc: --c99
  c include: .\api;..\..\..\..\..\sys\mid\api;..\..\..\..\..\sys\mid\inc;..\..\..\envcom;..\..\..\..\..\sys\abs\api;..\..\shalPART-package\shalPART\api;..\..\..\..\abslayer\hal-package\hal\hal-src\stm32
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\shalBASE.sct
  link misc: --entry shalbase_entrypoint --symdefs .\lib\shalBASE.obj
  group shalbase
    ./src/: shalBASE.c
  group hal
    ../../../../../sys/mid/src/: core_cm3.c system_stm32f10x.c
    ../../../../../sys/mid/lib/: stm32.lib
    ../../../../abslayer/hal-package/hal/hal-src/stm32/: hal_board_config.c hal_stm32.c hal_stm32_can.c hal_stm32_display.c hal_stm32_display_GLCD_SPI_STM32.c hal_stm32_eeprom.c hal_stm32_eth.c hal_stm32_flash.c hal_stm32_gpio.c hal_stm32_i2c.c hal_stm32_spi.c hal_stm32_sys.c
    ../../../../abslayer/hal-package/hal/hal-src/stm32/stm32_utility/: stm32_eval_i2c_ee.c
