# Keil uVision project shalbase-full.uvproj, settings and files
target mcsbstm2c (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: loader
  c flags: Optim=1
  c define: STM32F10X_CL
  c misc: --c99
  c include: ..\..\shalBASE\api;..\..\..\api;..\..\..\shalPART-package\shalPART\api;..\..\..\..\..\..\sys\mid\api;..\..\..\..\..\..\sys\mid\inc;..\..\..\..\envcom;..\..\..\..\..\..\sys\abs\api
  asm misc: --cpreproc
  asm include: ..\hal-cfg
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT10: RAM 0x20001000 size 0xf000
  group application
    ../app-test/: main_STM32F107.c
  group shalbase-src
    ../../shalBASE/src/: shalBASE.c
  group shalpart-from-body
    ../../../shalPART-package/shalPART/lib/: shalPART.obj
  group envcommon
    ../../../../envcom/: eEcommon.c
  group hal
    ../../../../../../sys/abs/lib/: hal.stm32.mcbstm32c.slim.lib
    ../../../../../../sys/abs/src/: hal_stm32_startup.s
    ../hal-cfg/: hal_cfg.h hal_cfg.c
